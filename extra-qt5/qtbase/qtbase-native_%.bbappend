FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://pc-cleanup.patch"
