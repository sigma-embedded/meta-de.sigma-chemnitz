FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
  file://tcp-listen.patch \
"
