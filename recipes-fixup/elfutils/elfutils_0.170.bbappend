FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://a01938d584b91e747167bb4b3f30ec300c4d6e43.patch \
"
