FILESEXTRAPATHS:prepend := "${THISDIR}/libdnf:"

SRC_URI += "\
    file://gcc13.patch \
"
