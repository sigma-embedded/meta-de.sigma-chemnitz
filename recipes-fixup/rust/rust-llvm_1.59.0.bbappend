FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://gcc-13.patch \
"
