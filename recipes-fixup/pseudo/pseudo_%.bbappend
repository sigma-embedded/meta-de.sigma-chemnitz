FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://no_abort.patch \
"
