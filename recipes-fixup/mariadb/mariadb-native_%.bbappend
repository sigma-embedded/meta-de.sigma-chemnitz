FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

#
SRC_URI += "\
    file://gcc13-fixup.patch \
"
