FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-tcpudp-do-not-keep-connection-open.patch"
