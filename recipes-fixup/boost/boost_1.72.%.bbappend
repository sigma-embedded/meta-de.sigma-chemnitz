FILESEXTRAPATHS:prepend := "${THISDIR}/boost:"

SRC_URI += "\
    file://74fb0a26099bc51d717f5f154b37231ce7df3e98.patch \
"
