FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://0014-linux-user-fix-to-handle-variably-sized-SIOCGSTAMP-w.patch \
"
