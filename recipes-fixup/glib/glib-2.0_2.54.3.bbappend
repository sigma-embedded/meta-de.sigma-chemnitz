FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://566e1d61a500267c7849ad0b2552feec9c9a29a6.patch \
"
