FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
  file://0001-hashtable-Remove-duplicate-hashtable_iterator_value-.patch \
"
