FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
  file://0001-added-SendClientId-option-to-disable-sending-of-dhcp.patch \
"
