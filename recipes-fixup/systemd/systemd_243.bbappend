FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://0001-added-SendClientId-option-to-disable-sending-of-dhcp.patch \
    file://d0122c077d2d8fd0fd29b463c501e7ddf9177ff3.patch \
"
