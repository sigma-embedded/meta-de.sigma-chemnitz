FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://nolto-libfix.patch \
"
