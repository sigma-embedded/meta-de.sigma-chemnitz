INCPATH := "${LAYERDIR_de.sigma-chemnitz.core}/xtra-bsp/barebox"

require ${INCPATH}/barebox.inc
require ${INCPATH}/barebox-tools.inc
require ${INCPATH}/barebox-common_2025.09.inc
