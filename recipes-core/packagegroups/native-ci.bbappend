DEPENDS += "\
    unfs3-native \
    ccache-native \
    rust-llvm-native \
"
