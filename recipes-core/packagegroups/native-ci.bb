## used to test '-native' dependencies in ci build; listing these
## packages in the packagegroup does not have an effect.

LICENSE = "CLOSED"
