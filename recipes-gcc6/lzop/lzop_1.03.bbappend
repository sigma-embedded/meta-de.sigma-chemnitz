FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

# aaab0e290ec7c4fb09a46a15d72d6aec6dedc832
SRC_URI += "file://lzop-1.03-gcc6.patch"
