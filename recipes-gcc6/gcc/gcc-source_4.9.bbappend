require ${THISDIR}/gcc-fixup.inc
