# ce1b37e29dc89b67dc698e856007b59faa16c4df
EXTRA_OECONF_class-native += "--disable-werror"
