FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://new-v4l2-ioctl.patch \
"
